v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {lab_wire.sym} -1990 -400 0 0 {name=p1 sig_type=std_logic lab=Cin verilog_type=reg}
C {lab_wire.sym} -1990 -440 0 0 {name=p2 sig_type=std_logic lab=A[0] verilog_type=reg}
C {lab_wire.sym} -1990 -420 0 0 {name=p3 sig_type=std_logic lab=B[0] verilog_type=reg}
C {lab_wire.sym} -1690 -420 0 1 {name=p4 sig_type=std_logic lab=n1}
C {lab_wire.sym} -1510 -440 0 0 {name=p5 sig_type=std_logic lab=A[1] verilog_type=reg}
C {lab_wire.sym} -1990 -260 0 0 {name=p6 sig_type=std_logic lab=A[2] verilog_type=reg}
C {lab_wire.sym} -1510 -260 0 0 {name=p7 sig_type=std_logic lab=A[3] verilog_type=reg}
C {lab_wire.sym} -1510 -420 0 0 {name=p8 sig_type=std_logic lab=B[1] verilog_type=reg}
C {lab_wire.sym} -1990 -240 0 0 {name=p9 sig_type=std_logic lab=B[2] verilog_type=reg}
C {lab_wire.sym} -1510 -240 0 0 {name=p10 sig_type=std_logic lab=B[3] verilog_type=reg}
C {lab_wire.sym} -1210 -440 0 1 {name=p11 sig_type=std_logic lab=Sum[1]}
C {lab_wire.sym} -1690 -260 0 1 {name=p12 sig_type=std_logic lab=Sum[2]}
C {lab_wire.sym} -1210 -260 0 1 {name=p13 sig_type=std_logic lab=Sum[3]}
C {lab_wire.sym} -1210 -240 0 1 {name=p14 sig_type=std_logic lab=Cout}
C {ipin.sym} -2300 -380 0 0 {name=p15 lab=A[3:0]}
C {ipin.sym} -2300 -340 0 0 {name=p16 lab=B[3:0]}
C {ipin.sym} -2300 -300 0 0 {name=p17 lab=Cin}
C {opin.sym} -2260 -360 0 0 {name=p18 lab=Sum[3:0]}
C {opin.sym} -2260 -320 0 0 {name=p19 lab=Cout}
C {ipin.sym} -2300 -260 0 0 {name=p20 lab=VDD}
C {ipin.sym} -2300 -220 0 0 {name=p21 lab=GND}
C {lab_pin.sym} -1990 -380 0 0 {name=p22 sig_type=std_logic lab=VDD}
C {lab_pin.sym} -1510 -380 0 0 {name=p23 sig_type=std_logic lab=VDD}
C {lab_pin.sym} -1990 -200 0 0 {name=p24 sig_type=std_logic lab=VDD}
C {lab_pin.sym} -1510 -200 0 0 {name=p25 sig_type=std_logic lab=VDD}
C {lab_pin.sym} -1990 -360 0 0 {name=p26 sig_type=std_logic lab=GND}
C {lab_pin.sym} -1510 -360 0 0 {name=p27 sig_type=std_logic lab=GND}
C {lab_pin.sym} -1990 -180 0 0 {name=p28 sig_type=std_logic lab=GND}
C {lab_pin.sym} -1510 -180 0 0 {name=p29 sig_type=std_logic lab=GND}
C {lab_wire.sym} -1690 -440 0 1 {name=p30 sig_type=std_logic lab=Sum[0]}
C {lab_wire.sym} -1510 -400 0 0 {name=p31 sig_type=std_logic lab=n1}
C {lab_wire.sym} -1210 -420 0 1 {name=p32 sig_type=std_logic lab=n2}
C {lab_wire.sym} -1990 -220 0 0 {name=p33 sig_type=std_logic lab=n2}
C {lab_wire.sym} -1690 -240 0 1 {name=p34 sig_type=std_logic lab=n3}
C {lab_wire.sym} -1510 -220 0 0 {name=p35 sig_type=std_logic lab=n3}
C {adder_1bit.sym} -1840 -400 0 0 {name=x1}
C {adder_1bit.sym} -1360 -400 0 0 {name=x2}
C {adder_1bit.sym} -1840 -220 0 0 {name=x3}
C {adder_1bit.sym} -1360 -220 0 0 {name=x4}
